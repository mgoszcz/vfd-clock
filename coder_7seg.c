/*
 * coder_7seg.c
 *
7 segment display code:

-----------------------------
|   CODE   |   CHARACTER    |
-----------------------------
|   0      |   0            |
-----------------------------
|   1      |   1            |
-----------------------------
|   2      |   2            |
-----------------------------
|   3      |   3            |
-----------------------------
|   4      |   4            |
-----------------------------
|   5      |   5            |
-----------------------------
|   6      |   6            |
-----------------------------
|   7      |   7            |
-----------------------------
|   8      |   8            |
-----------------------------
|   9      |   9            |
-----------------------------
|   10     |   0.           |
-----------------------------
|   11     |   1.           |
-----------------------------
|   12     |   2.           |
-----------------------------
|   13     |   3.           |
-----------------------------
|   14     |   4.           |
-----------------------------
|   15     |   5.           |
-----------------------------
|   16     |   6.           |
-----------------------------
|   17     |   7.           |
-----------------------------
|   18     |   8.           |
-----------------------------
|   19     |   9.           |
-----------------------------
|   20     |                |
-----------------------------
|   21     |   A            |
-----------------------------
|   22     |   B            |
-----------------------------
|   23     |   C            |
-----------------------------
|   24     |   D            |
-----------------------------
|   25     |   E            |
-----------------------------
|   26     |   F            |
-----------------------------
|   27     |   G            |
-----------------------------
|   28     |   H            |
-----------------------------
|   29     |   L            |
-----------------------------
|   30     |   N            |
-----------------------------
|   31     |   O            |
-----------------------------
|   32     |   P            |
-----------------------------
|   33     |   R            |
-----------------------------
|   34     |   T            |
-----------------------------
|   35     |   U            |
-----------------------------
|   41     |   A.           |
-----------------------------
|   42     |   B.           |
-----------------------------
|   43     |   C.           |
-----------------------------
|   44     |   D.           |
-----------------------------
|   45     |   E.           |
-----------------------------
|   46     |   F.           |
-----------------------------
|   47     |   G.           |
-----------------------------
|   48     |   H.           |
-----------------------------
|   49     |   L.           |
-----------------------------
|   50     |   N.           |
-----------------------------
|   51     |   O.           |
-----------------------------
|   52     |   P.           |
-----------------------------
|   53     |   R.           |
-----------------------------
|   54     |   T.           |
-----------------------------
|   55     |   U.           |
-----------------------------
|   60     |   degree       |
-----------------------------
|   61     |   .            |
-----------------------------
|   62     |   -            |
-----------------------------
...
-----------------------------
|   100    |   segment A    |
-----------------------------
|   101    |   segment B    |
-----------------------------
|   102    |   segment C    |
-----------------------------
|   103    |   segment D    |
-----------------------------
|   104    |   segment E    |
-----------------------------
|   105    |   segment F    |
-----------------------------
|   106    |   segment G    |
-----------------------------
|   107    |   segment DP   |
-----------------------------

 * 7 segment display segments:
	A
  ------
 |      |
 | F    | B
 |   G  |
  ------
 |	    |
 | E    | C
 |      |
  ------  .
     D     DP
 7 segment display binary representation
	0b00000000 - DP, G, F, E, D, C, B, A
 */ 

const unsigned char digitsTable[10] = {
	0b00111111, 0b00000110, 0b01011011, 0b01001111, 0b01100110, 0b01101101, 0b01111101, 0b00000111, 0b01111111, 0b01101111
};

const unsigned char lettersTable[15] = {
	0b01110111, 0b01111100, 0b00111001, 0b01011110, 0b01111001, 0b01110001, 0b00111101, 0b01110100, 0b00111000, 0b01010100, 0b01011100, 0b01110011, 0b01010000, 0b01111000, 0b00011100
};

const unsigned char symbolsTable[3] = {0b01100011, 0b10000000, 0b01000000};

const unsigned char segmentsTable[8] = {0b1, 0b10, 0b100, 0b1000, 0b10000, 0b100000, 0b1000000, 0b10000000};
	
unsigned char codeToDisplay(int code) {
	switch (code / 10) {
		case 0:
			return digitsTable[code];
		case 1:
			return digitsTable[code - 10] + symbolsTable[1];
		case 2:
			if (code == 20) {
				return 0;
			}
			return lettersTable[code - 21];
		case 3:
			if (code > 35) return 0;
			return lettersTable[code - 21];
		case 4:
			if (code == 40) {
				return 0;
			}
			return lettersTable[code - 41] + symbolsTable[1];
		case 5:
			if (code > 55) return 0;
			return lettersTable[code - 41] + symbolsTable[1];
		case 6:
			return symbolsTable[code - 60];
		case 10:
			return segmentsTable[code - 100];
	}
	return 0;
}